## boards/shields/seb_makropad/Kconfig.defconfig
```kconfig
if SHIELD_SEB_MAKROPAD

config ZMK_KEYBOARD_NAME
    default "Seb Makropad"

endif
```
